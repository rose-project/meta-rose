

CMAKE_EXTRACONF += "\
	-DCMAKE_BOOTSTRAP=1 -DCMAKE_USE_OPENSSL=ON \
    "
