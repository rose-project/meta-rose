require rose-image-minimal.bb

DESCRIPTION = "Image which adds graphic supports to minimal image."


#IMAGE_INSTALL = "packagegroup-core-boot ${ROOTFS_PKGMANAGE_BOOTSTRAP} ${CORE_IMAGE_EXTRA_INSTALL}"
