require rose-image-gfx.bb

DESCRIPTION = "Creates a full developer SDK with all needed sources"

IMAGE_FEATURES += "dev-pkgs"
